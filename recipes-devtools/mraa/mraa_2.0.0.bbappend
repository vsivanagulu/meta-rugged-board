FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-FindNodejs.cmake-parse-V8_MAJOR_VERSION-from-nodejs-.patch \
            file://0001-mraa-Add-platform-support-for-Rugged-board-SAMA5D27.patch \
"
